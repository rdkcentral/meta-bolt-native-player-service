SUMMARY = "bolt image for nativeplayer"

inherit base-bolt-image

IMAGE_INSTALL += "nativeplayer"
